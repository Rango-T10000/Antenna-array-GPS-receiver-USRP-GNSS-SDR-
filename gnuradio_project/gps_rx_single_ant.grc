options:
  parameters:
    author: rango
    generate_options: qt_gui
    id: gps_rx_single_ant
    output_language: python
    title: gps_rx_single_ant
  states: {}

blocks:
- name: ant0
  id: variable
  parameters:
    value: '"/home/ssd2/gnss-sdr/fsc_data/data/ant0_ .dat" '
  states: {}
- name: freq
  id: variable
  parameters:
    value: 1.57542e9
  states: {}
- name: gain
  id: variable
  parameters:
    value: '58'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.8'
    freq: 1e6
    offset: '0.1'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: ant0
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    bw0: samp_rate
    center_freq0: freq
    gain0: '5'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX1"'
    center_freq0: freq
    clock_source0: external
    dc_offs_enb0: auto
    gain0: gain
    samp_rate: samp_rate
    sd_spec0: A:0
    sync: none
    time_source0: external
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
